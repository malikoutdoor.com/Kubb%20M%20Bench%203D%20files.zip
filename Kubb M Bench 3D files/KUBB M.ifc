Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T16:28:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 16:28:29 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{7F712296-4F9B-472E-B161-216AC0D72261}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 16:28:28 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 16:28:28 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 16:28:28 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR052 - GRANITO, Panca KUBB M:0PAAR052 - GRANITO:134946
In: 0 - Piano Terra
Type - Material: GRANITO
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca KUBB M
Type - Dati identità - BIM Name: KUBB M; BIM Object Type: SEDUTE - BENCHES; Code: 0PAAR052; Designer: BELLITALIA DESIGN; Family Name: KUBB; Nome del tipo: 0PAAR052 - GRANITO; URL Eng: https://www.bellitalia.net/en/products/benches/kubb-benches/; URL Ita: https://www.bellitalia.net/prodotti/panchine/kubb-benches/
Type - Dimensioni - Dimensions: 700 mm X 650 mm X 440 mm
Type - Generale - Descrizione Tecnica Famiglia: "panca a sezione rettangolare modulare mod. “KUBB M”, costituita da una panca monolitica dotata di scuretto alla base."; Descrizione Tecnica per Codice: PANCA KUBB M IN GRANITO (COLORE A SCELTA) SABBIATO CON PIANO DI SEDUTA SPAZZOLATO VERNICIATURA ANTI-DEGRADO; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "modular rectangular section bench mod. “KUBB M”, consisting of a monolithic bench equipped with dark at the base."; Technical Description for Article: KUBB M BENCH IN GRANITO (COLOR TO BE CHOSEN) SANDBLASTED WITH BRUSHED SEAT SURFACE ANTI-DECAY VARNISH
Type - Materiali e finiture - Materiale Principale: Granito Bianco; Materiale Secondario: Granito; MATERIALE SEDUTA: GRANITO; Primary Material: Reconstituted White Granite Granito; Secondary Material: Reconstituted Granite
Type - Meccanica - Weight ( kg): 472 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR052 - GRANITO
Altro - Famiglia: Panca KUBB M: 0PAAR052 - GRANITO; Famiglia e tipo: Panca KUBB M: 0PAAR052 - GRANITO; ID tipo: Panca KUBB M: 0PAAR052 - GRANITO; Tipo: Panca KUBB M: 0PAAR052 - GRANITO
Dimensioni - Area: 1.02081 m2; Volume: 0.192474 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
